# Keil uVision project Timer_master_project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Timer_master_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\FreeRtos\include;..\FreeRtos\portable\ARM_CM3;..\User;..\Library\STM32F10x_StdPeriph_Driver\inc;..\Library\CMSIS;..\User\delay-FreeRTOS;..\BSP\USART;..\BSP\TIMER;..\BSP\KEY;..\BSP\EXTI;..\BSP\INTERFACE;..\BSP\GT30132S4;..\BSP\ILI9486;..\BSP\BUTTON;..\BSP\SPI;..\BSP\BEEP;..\BSP\LOAR;..\BSP\IWDG;..\BSP\EM5820
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Library/CMSIS/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ../User/: main.c FreeRTOSConfig.h stm32f10x_conf.h stm32f10x_it.c
    ../User/delay-FreeRTOS/: bsp_delay.c
  group BSP
    ../BSP/USART/: bsp_usart.c
    ../BSP/TIMER/: bsp_timer.c
    ../BSP/KEY/: bsp_key.c
    ../BSP/BUTTON/: bsp_button.c
    ../BSP/EXTI/: bsp_exti.c
    ../BSP/INTERFACE/: bsp_interface.c
    ../BSP/ILI9486/: ili9486.c
    ../BSP/SPI/: bsp_spi.c
    ../BSP/GT30132S4/: GT30l32S4W.c
    ../BSP/BEEP/: bsp_beep.c
    ../BSP/LOAR/: as32-100-c.c
    ../BSP/IWDG/: bsp_iwdg.c
    ../BSP/EM5820/: DP_Print_lib.c
  group FreeRTOS/Source
    ../FreeRtos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRtos/portable/ARM_CM3/: port.c
    ../FreeRtos/portable/MemMang/: heap_4.c
  group DOS
    ../Doc/: readme.txt
